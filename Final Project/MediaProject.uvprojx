# Keil uVision project MediaProject.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MediaProject
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: U:\coe718\project\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: LPC17xx.h system_LPC17xx.c brick_breaker.c flappy_bird.c game_menu.c GLCD_SPI_LPC1700.c image.c KBD.c LED.c Main.c photo_gallery.c LED.h KBD.h GLCD.h Font_6x8_h.h Font_16x24_h.h
    ../LCD_Blinky/: ARM_Ani_16bpp.c Bg_16bpp_l.c Bg_16bpp_r.c core_cm3.c Bg_16bpp_t.c IRQ.c
software components: CMSIS:CORE 5.4.0
